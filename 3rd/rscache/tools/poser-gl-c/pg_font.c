#include "pg_font.h"

#include <string.h>

/*
 * Glyphs, seven rows of five columns each, '#' lit.
 *
 * Written as art rather than as packed hex on purpose: a transcription error in
 * a hex table is invisible until the glyph is on screen, whereas a wrong pixel
 * here is visible in the diff. `--font-specimen` renders the whole set to a BMP
 * for the same reason.
 */
static const char* const GLYPHS[][PG_FONT_GLYPH_H] = {
    /* 32 ' ' */ { "     ", "     ", "     ", "     ", "     ", "     ", "     " },
    /* 33 '!' */ { "  #  ", "  #  ", "  #  ", "  #  ", "  #  ", "     ", "  #  " },
    /* 34 '"' */ { " # # ", " # # ", "     ", "     ", "     ", "     ", "     " },
    /* 35 '#' */ { " # # ", " # # ", "#####", " # # ", "#####", " # # ", " # # " },
    /* 36 '$' */ { "  #  ", " ####", "# #  ", " ### ", "  # #", "#### ", "  #  " },
    /* 37 '%' */ { "##  #", "## # ", "   # ", "  #  ", " #   ", " # ##", "#  ##" },
    /* 38 '&' */ { " ##  ", "#  # ", "#  # ", " ##  ", "#  # ", "#   #", " ### " },
    /* 39 '\'' */ { "  #  ", "  #  ", "     ", "     ", "     ", "     ", "     " },
    /* 40 '(' */ { "   # ", "  #  ", " #   ", " #   ", " #   ", "  #  ", "   # " },
    /* 41 ')' */ { " #   ", "  #  ", "   # ", "   # ", "   # ", "  #  ", " #   " },
    /* 42 '*' */ { "     ", " # # ", "  #  ", "#####", "  #  ", " # # ", "     " },
    /* 43 '+' */ { "     ", "  #  ", "  #  ", "#####", "  #  ", "  #  ", "     " },
    /* 44 ',' */ { "     ", "     ", "     ", "     ", "     ", "  #  ", " #   " },
    /* 45 '-' */ { "     ", "     ", "     ", "#####", "     ", "     ", "     " },
    /* 46 '.' */ { "     ", "     ", "     ", "     ", "     ", "     ", "  #  " },
    /* 47 '/' */ { "    #", "    #", "   # ", "  #  ", " #   ", "#    ", "#    " },
    /* 48 '0' */ { " ### ", "#   #", "#  ##", "# # #", "##  #", "#   #", " ### " },
    /* 49 '1' */ { "  #  ", " ##  ", "  #  ", "  #  ", "  #  ", "  #  ", " ### " },
    /* 50 '2' */ { " ### ", "#   #", "    #", "   # ", "  #  ", " #   ", "#####" },
    /* 51 '3' */ { "#####", "   # ", "  #  ", "   # ", "    #", "#   #", " ### " },
    /* 52 '4' */ { "   # ", "  ## ", " # # ", "#  # ", "#####", "   # ", "   # " },
    /* 53 '5' */ { "#####", "#    ", "#### ", "    #", "    #", "#   #", " ### " },
    /* 54 '6' */ { "  ## ", " #   ", "#    ", "#### ", "#   #", "#   #", " ### " },
    /* 55 '7' */ { "#####", "    #", "   # ", "  #  ", " #   ", " #   ", " #   " },
    /* 56 '8' */ { " ### ", "#   #", "#   #", " ### ", "#   #", "#   #", " ### " },
    /* 57 '9' */ { " ### ", "#   #", "#   #", " ####", "    #", "   # ", " ##  " },
    /* 58 ':' */ { "     ", "  #  ", "  #  ", "     ", "  #  ", "  #  ", "     " },
    /* 59 ';' */ { "     ", "  #  ", "  #  ", "     ", "  #  ", "  #  ", " #   " },
    /* 60 '<' */ { "   # ", "  #  ", " #   ", "#    ", " #   ", "  #  ", "   # " },
    /* 61 '=' */ { "     ", "     ", "#####", "     ", "#####", "     ", "     " },
    /* 62 '>' */ { " #   ", "  #  ", "   # ", "    #", "   # ", "  #  ", " #   " },
    /* 63 '?' */ { " ### ", "#   #", "    #", "   # ", "  #  ", "     ", "  #  " },
    /* 64 '@' */ { " ### ", "#   #", "# ###", "# # #", "# ###", "#    ", " ### " },
    /* 65 'A' */ { " ### ", "#   #", "#   #", "#####", "#   #", "#   #", "#   #" },
    /* 66 'B' */ { "#### ", "#   #", "#   #", "#### ", "#   #", "#   #", "#### " },
    /* 67 'C' */ { " ### ", "#   #", "#    ", "#    ", "#    ", "#   #", " ### " },
    /* 68 'D' */ { "#### ", "#   #", "#   #", "#   #", "#   #", "#   #", "#### " },
    /* 69 'E' */ { "#####", "#    ", "#    ", "#### ", "#    ", "#    ", "#####" },
    /* 70 'F' */ { "#####", "#    ", "#    ", "#### ", "#    ", "#    ", "#    " },
    /* 71 'G' */ { " ### ", "#   #", "#    ", "#  ##", "#   #", "#   #", " ### " },
    /* 72 'H' */ { "#   #", "#   #", "#   #", "#####", "#   #", "#   #", "#   #" },
    /* 73 'I' */ { " ### ", "  #  ", "  #  ", "  #  ", "  #  ", "  #  ", " ### " },
    /* 74 'J' */ { "   ##", "    #", "    #", "    #", "    #", "#   #", " ### " },
    /* 75 'K' */ { "#   #", "#  # ", "# #  ", "##   ", "# #  ", "#  # ", "#   #" },
    /* 76 'L' */ { "#    ", "#    ", "#    ", "#    ", "#    ", "#    ", "#####" },
    /* 77 'M' */ { "#   #", "## ##", "# # #", "#   #", "#   #", "#   #", "#   #" },
    /* 78 'N' */ { "#   #", "##  #", "# # #", "#  ##", "#   #", "#   #", "#   #" },
    /* 79 'O' */ { " ### ", "#   #", "#   #", "#   #", "#   #", "#   #", " ### " },
    /* 80 'P' */ { "#### ", "#   #", "#   #", "#### ", "#    ", "#    ", "#    " },
    /* 81 'Q' */ { " ### ", "#   #", "#   #", "#   #", "# # #", "#  # ", " ## #" },
    /* 82 'R' */ { "#### ", "#   #", "#   #", "#### ", "# #  ", "#  # ", "#   #" },
    /* 83 'S' */ { " ####", "#    ", "#    ", " ### ", "    #", "    #", "#### " },
    /* 84 'T' */ { "#####", "  #  ", "  #  ", "  #  ", "  #  ", "  #  ", "  #  " },
    /* 85 'U' */ { "#   #", "#   #", "#   #", "#   #", "#   #", "#   #", " ### " },
    /* 86 'V' */ { "#   #", "#   #", "#   #", "#   #", "#   #", " # # ", "  #  " },
    /* 87 'W' */ { "#   #", "#   #", "#   #", "# # #", "# # #", "## ##", "#   #" },
    /* 88 'X' */ { "#   #", "#   #", " # # ", "  #  ", " # # ", "#   #", "#   #" },
    /* 89 'Y' */ { "#   #", "#   #", " # # ", "  #  ", "  #  ", "  #  ", "  #  " },
    /* 90 'Z' */ { "#####", "    #", "   # ", "  #  ", " #   ", "#    ", "#####" },
    /* 91 '[' */ { " ### ", " #   ", " #   ", " #   ", " #   ", " #   ", " ### " },
    /* 92 '\\' */ { "#    ", "#    ", " #   ", "  #  ", "   # ", "    #", "    #" },
    /* 93 ']' */ { " ### ", "   # ", "   # ", "   # ", "   # ", "   # ", " ### " },
    /* 94 '^' */ { "  #  ", " # # ", "#   #", "     ", "     ", "     ", "     " },
    /* 95 '_' */ { "     ", "     ", "     ", "     ", "     ", "     ", "#####" },
    /* 96 '`' */ { " #   ", "  #  ", "     ", "     ", "     ", "     ", "     " },
    /* 97 'a' */ { "     ", "     ", " ### ", "    #", " ####", "#   #", " ####" },
    /* 98 'b' */ { "#    ", "#    ", "#### ", "#   #", "#   #", "#   #", "#### " },
    /* 99 'c' */ { "     ", "     ", " ### ", "#    ", "#    ", "#    ", " ### " },
    /* 100 'd' */ { "    #", "    #", " ####", "#   #", "#   #", "#   #", " ####" },
    /* 101 'e' */ { "     ", "     ", " ### ", "#   #", "#####", "#    ", " ### " },
    /* 102 'f' */ { "  ## ", " #  #", " #   ", "#### ", " #   ", " #   ", " #   " },
    /* 103 'g' */ { "     ", " ####", "#   #", "#   #", " ####", "    #", " ### " },
    /* 104 'h' */ { "#    ", "#    ", "#### ", "#   #", "#   #", "#   #", "#   #" },
    /* 105 'i' */ { "  #  ", "     ", " ##  ", "  #  ", "  #  ", "  #  ", " ### " },
    /* 106 'j' */ { "   # ", "     ", "  ## ", "   # ", "   # ", "#  # ", " ##  " },
    /* 107 'k' */ { "#    ", "#    ", "#  # ", "# #  ", "##   ", "# #  ", "#  # " },
    /* 108 'l' */ { " ##  ", "  #  ", "  #  ", "  #  ", "  #  ", "  #  ", " ### " },
    /* 109 'm' */ { "     ", "     ", "## # ", "# # #", "# # #", "# # #", "# # #" },
    /* 110 'n' */ { "     ", "     ", "#### ", "#   #", "#   #", "#   #", "#   #" },
    /* 111 'o' */ { "     ", "     ", " ### ", "#   #", "#   #", "#   #", " ### " },
    /* 112 'p' */ { "     ", "     ", "#### ", "#   #", "#### ", "#    ", "#    " },
    /* 113 'q' */ { "     ", "     ", " ####", "#   #", " ####", "    #", "    #" },
    /* 114 'r' */ { "     ", "     ", "# ## ", "##  #", "#    ", "#    ", "#    " },
    /* 115 's' */ { "     ", "     ", " ####", "#    ", " ### ", "    #", "#### " },
    /* 116 't' */ { " #   ", " #   ", "#### ", " #   ", " #   ", " #  #", "  ## " },
    /* 117 'u' */ { "     ", "     ", "#   #", "#   #", "#   #", "#   #", " ####" },
    /* 118 'v' */ { "     ", "     ", "#   #", "#   #", "#   #", " # # ", "  #  " },
    /* 119 'w' */ { "     ", "     ", "#   #", "# # #", "# # #", "# # #", " # # " },
    /* 120 'x' */ { "     ", "     ", "#   #", " # # ", "  #  ", " # # ", "#   #" },
    /* 121 'y' */ { "     ", "     ", "#   #", "#   #", " ####", "    #", " ### " },
    /* 122 'z' */ { "     ", "     ", "#####", "   # ", "  #  ", " #   ", "#####" },
    /* 123 '{' */ { "   ##", "  #  ", "  #  ", " #   ", "  #  ", "  #  ", "   ##" },
    /* 124 '|' */ { "  #  ", "  #  ", "  #  ", "  #  ", "  #  ", "  #  ", "  #  " },
    /* 125 '}' */ { "##   ", "  #  ", "  #  ", "   # ", "  #  ", "  #  ", "##   " },
    /* 126 '~' */ { "     ", "     ", " #  #", "# # #", "#  # ", "     ", "     " },
};

#define PG_FONT_GLYPH_COUNT ((int)(sizeof(GLYPHS) / sizeof(GLYPHS[0])))

static unsigned char g_atlas[PG_FONT_ATLAS_W * PG_FONT_ATLAS_H];
static PG_GLuint g_texture = 0;
static int g_baked = 0;

static void
bake(void)
{
    if( g_baked )
        return;
    memset(g_atlas, 0, sizeof(g_atlas));
    for( int i = 0; i < PG_FONT_GLYPH_COUNT; i++ )
    {
        int cx = (i % PG_FONT_ATLAS_COLS) * PG_FONT_CELL_W;
        int cy = (i / PG_FONT_ATLAS_COLS) * PG_FONT_CELL_H;
        for( int row = 0; row < PG_FONT_GLYPH_H; row++ )
        {
            const char* line = GLYPHS[i][row];
            for( int col = 0; col < PG_FONT_GLYPH_W; col++ )
            {
                if( line[col] == '#' )
                    g_atlas[(cy + row) * PG_FONT_ATLAS_W + (cx + col)] = 255;
            }
        }
    }
    g_baked = 1;
}

int
pg_font_init(void)
{
    bake();
    pg_glGenTextures(1, &g_texture);
    if( !g_texture )
        return -1;
    pg_glBindTexture(GL_TEXTURE_2D, g_texture);
    pg_glPixelStorei(GL_UNPACK_ALIGNMENT, 1);
    pg_glTexImage2D(
        GL_TEXTURE_2D,
        0,
        GL_R8,
        PG_FONT_ATLAS_W,
        PG_FONT_ATLAS_H,
        0,
        GL_RED,
        GL_UNSIGNED_BYTE,
        g_atlas);
    pg_glTexParameteri(GL_TEXTURE_2D, GL_TEXTURE_MIN_FILTER, GL_NEAREST);
    pg_glTexParameteri(GL_TEXTURE_2D, GL_TEXTURE_MAG_FILTER, GL_NEAREST);
    pg_glTexParameteri(GL_TEXTURE_2D, GL_TEXTURE_WRAP_S, GL_CLAMP_TO_EDGE);
    pg_glTexParameteri(GL_TEXTURE_2D, GL_TEXTURE_WRAP_T, GL_CLAMP_TO_EDGE);
    pg_glBindTexture(GL_TEXTURE_2D, 0);
    return 0;
}

void
pg_font_free(void)
{
    if( g_texture )
        pg_glDeleteTextures(1, &g_texture);
    g_texture = 0;
}

PG_GLuint
pg_font_texture(void)
{
    return g_texture;
}

void
pg_font_cell(char c, int* out_x, int* out_y)
{
    int index = (unsigned char)c - PG_FONT_FIRST_CHAR;
    if( index < 0 || index >= PG_FONT_GLYPH_COUNT )
        index = '?' - PG_FONT_FIRST_CHAR;
    *out_x = (index % PG_FONT_ATLAS_COLS) * PG_FONT_CELL_W;
    *out_y = (index / PG_FONT_ATLAS_COLS) * PG_FONT_CELL_H;
}

int
pg_font_text_width(const char* text)
{
    if( !text )
        return 0;
    return (int)strlen(text) * PG_FONT_CELL_W;
}

const unsigned char*
pg_font_atlas_pixels(void)
{
    bake();
    return g_atlas;
}
