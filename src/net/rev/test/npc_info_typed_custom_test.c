/*
 * NPC_INFO's typed customisation blocks (BodyCustomisationV1/V2 and the head
 * ones): their recolour and retexture lists carry no count, the npc TYPE's
 * lists decide it (deob Statics ~47320: field1237.field5139 / field5158
 * .length), so the reader asks the host (RsprotNpcTypeLengths).
 *
 * The two frames below are real wire bytes: NPC_INFO_LARGE packets from
 * RSProx recordings, rev 226 (rsprox.net 1703, frame 110105, tick 7205: four
 * Abyssal axons, type 12375, three recolours each) and rev 234 (rsprox.net
 * 3285, frame 289111, tick 21465: ten Lost Souls, type 12212, four each). The
 * expected colours are RSProx's own transcript of the same packets, which
 * read the lengths off the cache. Without the type answer those frames ended
 * at their first typed block and every npc record after it went unread (29
 * records in 1703, 66 in 3285 and 38 in 3299 over the whole recordings).
 */
#include "net/proto/proto_info.h"
#include "rsprot_buf.h"
#include "streams/npc_info.h"
#include "streams/rsprot_info.h"

#include <stdio.h>
#include <string.h>

static int g_failures;

#define CHECK(cond, what)                                                                \
    do                                                                                   \
    {                                                                                    \
        if( cond )                                                                       \
            printf("  ok: %s\n", what);                                                  \
        else                                                                             \
        {                                                                                \
            printf("  FAIL: %s (%s:%d)\n", what, __FILE__, __LINE__);                    \
            g_failures++;                                                                \
        }                                                                                \
    } while( 0 )

struct TypedBlock
{
    int position;
    int type;
    int count;
    int recolours[8];
};

static uint8_t const k_osrs226_frame[496] = {
    0x02, 0xff, 0xfd, 0x8b, 0x28, 0x45, 0x40, 0x00, 0xbc, 0x15, 0xb8, 0x2b,
    0xbf, 0xda, 0xf2, 0x8a, 0x2c, 0x00, 0x0b, 0xc1, 0x5b, 0x82, 0xcb, 0xfd,
    0x93, 0x48, 0x4e, 0xc0, 0x00, 0xbc, 0x15, 0xb8, 0x2b, 0xbf, 0xdd, 0xf3,
    0x07, 0xf4, 0x00, 0x0b, 0xc1, 0x59, 0x82, 0x73, 0xfd, 0xa3, 0x44, 0xaa,
    0x40, 0x00, 0xbc, 0x15, 0xb8, 0x2c, 0x3f, 0xda, 0xb3, 0xc9, 0xb4, 0x00,
    0x0b, 0xc1, 0x5b, 0x82, 0xcb, 0xfd, 0xb3, 0x44, 0xb9, 0x40, 0x00, 0xbc,
    0x15, 0xb8, 0x2c, 0xbf, 0xde, 0x75, 0xc0, 0xb4, 0x00, 0x0b, 0xc1, 0x59,
    0x82, 0x73, 0xfd, 0x8f, 0x4c, 0x22, 0xc0, 0x00, 0xbc, 0x15, 0xb8, 0x2b,
    0xbf, 0xd9, 0x76, 0x03, 0x9c, 0x00, 0x0b, 0xc1, 0x5b, 0x82, 0xbb, 0xfd,
    0x9b, 0x4c, 0xa0, 0xc0, 0x00, 0xbc, 0x15, 0xb8, 0x2c, 0x3f, 0xd9, 0xf5,
    0x4a, 0x9c, 0x00, 0x0b, 0xc1, 0x5b, 0x82, 0xc3, 0xfd, 0xa7, 0x4c, 0xb3,
    0x40, 0x00, 0xbc, 0x15, 0xb8, 0x2c, 0x3f, 0xdb, 0xb6, 0x0d, 0x9c, 0x00,
    0x0b, 0xc1, 0x5b, 0x82, 0x5b, 0xfd, 0xeb, 0x87, 0xf7, 0x40, 0x00, 0xbc,
    0x15, 0x98, 0x27, 0x3f, 0xdb, 0xf7, 0xc5, 0xa4, 0x00, 0x0b, 0xc1, 0x5b,
    0x82, 0x5b, 0xfd, 0xdb, 0x88, 0x87, 0x40, 0x00, 0xbc, 0x15, 0x98, 0x27,
    0x3f, 0xdb, 0x77, 0x4a, 0xac, 0x00, 0x0b, 0xc1, 0x5b, 0x82, 0xcb, 0xfd,
    0xcb, 0x8c, 0x0e, 0xc0, 0x00, 0xbc, 0x15, 0xb8, 0x25, 0x3f, 0xdc, 0x39,
    0xc6, 0xf4, 0x00, 0x0b, 0xc1, 0x5b, 0x82, 0x53, 0xfd, 0xd3, 0x8c, 0xcb,
    0x40, 0x00, 0xbc, 0x15, 0x98, 0x27, 0x3f, 0xdc, 0xfc, 0x7f, 0x44, 0x00,
    0x0b, 0xc1, 0x5b, 0x82, 0x53, 0xfd, 0xc7, 0xb4, 0x26, 0xc0, 0x00, 0xbc,
    0x15, 0xb8, 0x25, 0x3f, 0xdd, 0x7c, 0x09, 0xf4, 0x00, 0x0b, 0xc1, 0x59,
    0x82, 0x73, 0xfd, 0xe3, 0xe0, 0x23, 0x40, 0x00, 0xbc, 0x15, 0x98, 0x27,
    0x3f, 0xff, 0xc0, 0x88, 0x46, 0x89, 0x7c, 0x9e, 0x29, 0x9e, 0x40, 0x9e,
    0x1e, 0x41, 0x62, 0x79, 0x73, 0x73, 0x61, 0x6c, 0x20, 0x41, 0x78, 0x6f,
    0x6e, 0x20, 0x28, 0x57, 0x61, 0x74, 0x65, 0x72, 0x29, 0x00, 0x49, 0x26,
    0x18, 0x0d, 0xff, 0x08, 0x45, 0x26, 0x2b, 0x0d, 0xff, 0x88, 0x46, 0x89,
    0x7c, 0x4e, 0x2d, 0x4d, 0xc0, 0x4e, 0x9e, 0x41, 0x62, 0x79, 0x73, 0x73,
    0x61, 0x6c, 0x20, 0x41, 0x78, 0x6f, 0x6e, 0x20, 0x28, 0x4e, 0x61, 0x74,
    0x75, 0x72, 0x65, 0x29, 0x00, 0x4d, 0x26, 0x16, 0x0d, 0xff, 0x08, 0x50,
    0x26, 0x2f, 0x0d, 0xff, 0x08, 0x4c, 0x26, 0x29, 0x0d, 0xff, 0x08, 0x50,
    0x26, 0x35, 0x0d, 0xff, 0x88, 0x46, 0x89, 0x7c, 0x02, 0x29, 0x02, 0x3d,
    0x02, 0x1e, 0x41, 0x62, 0x79, 0x73, 0x73, 0x61, 0x6c, 0x20, 0x41, 0x78,
    0x6f, 0x6e, 0x20, 0x28, 0x46, 0x69, 0x72, 0x65, 0x29, 0x00, 0x4e, 0x26,
    0x0b, 0x0d, 0xff, 0x88, 0x46, 0x89, 0x7c, 0x26, 0x58, 0x25, 0xc8, 0x26,
    0x31, 0x41, 0x62, 0x79, 0x73, 0x73, 0x61, 0x6c, 0x20, 0x41, 0x78, 0x6f,
    0x6e, 0x20, 0x28, 0x43, 0x6f, 0x73, 0x6d, 0x69, 0x63, 0x29, 0x00, 0x53,
    0x26, 0x13, 0x0d, 0xff, 0x08, 0x50, 0x26, 0x2f, 0x0d, 0xff, 0x08, 0x50,
    0x26, 0x2f, 0x0d, 0xff, 0x08, 0x50, 0x26, 0x2f, 0x0d, 0xff, 0x08, 0x51,
    0x26, 0x3b, 0x0d, 0x00, 0x08, 0x60, 0x26, 0x1b, 0x0d, 0x00, 0x08, 0x58,
    0x26, 0x2d, 0x0d, 0xff, 0x08, 0x5c, 0x26, 0x04, 0x0d, 0x00, 0x08, 0x64,
    0x26, 0x1c, 0x0d, 0x00, 0x08, 0x6a, 0x26, 0x06, 0x0d, 0x00, 0x08, 0x66,
    0x26, 0x0a, 0x0d, 0x00,
};
static struct TypedBlock const k_osrs226_frame_blocks[] = {
    { 0, 12375, 3, { 40489, 40512, 40478 } },
    { 2, 12375, 3, { 20013, 19904, 20126 } },
    { 8, 12375, 3, { 553, 573, 542 } },
    { 9, 12375, 3, { 9816, 9672, 9777 } },
};

static uint8_t const k_osrs234_frame[412] = {
    0x0d, 0xff, 0xff, 0xff, 0xff, 0xff, 0xcb, 0x99, 0xbe, 0xd1, 0xe0, 0x00,
    0x68, 0x26, 0x9e, 0xe1, 0x5c, 0xb9, 0xdb, 0xed, 0x1e, 0x00, 0x06, 0x82,
    0x69, 0xee, 0x11, 0xcb, 0xa1, 0xbe, 0xd1, 0xe0, 0x00, 0x68, 0x26, 0x9e,
    0xa1, 0x1b, 0x80, 0xbb, 0xeb, 0x3e, 0x00, 0x06, 0x81, 0x6f, 0xf8, 0x07,
    0xcb, 0xbd, 0xbe, 0xd1, 0x60, 0x00, 0x68, 0x26, 0x80, 0x21, 0x5c, 0xbc,
    0x1b, 0xed, 0x16, 0x00, 0x06, 0x82, 0x68, 0x06, 0x11, 0xcb, 0xa5, 0xbe,
    0xd1, 0x20, 0x00, 0x68, 0x26, 0x9e, 0xa0, 0x3c, 0xba, 0x9b, 0xed, 0x0a,
    0x00, 0x06, 0x82, 0x69, 0xef, 0xff, 0xcb, 0xad, 0xbe, 0xd0, 0xa0, 0x00,
    0x68, 0x26, 0x9f, 0x3f, 0xbc, 0xbb, 0x1b, 0xed, 0x02, 0x00, 0x06, 0x82,
    0x68, 0x07, 0xfb, 0xcb, 0xb5, 0xbe, 0xd0, 0x20, 0x00, 0x68, 0x26, 0x80,
    0x7f, 0xfc, 0xbb, 0x9b, 0xed, 0x02, 0x00, 0x06, 0x82, 0x68, 0x0b, 0xff,
    0xcb, 0xc5, 0xbe, 0xd0, 0xe0, 0x00, 0x68, 0x26, 0x80, 0xa0, 0xdf, 0xff,
    0xe0, 0x15, 0x04, 0x53, 0x61, 0x6e, 0x69, 0x74, 0x61, 0x73, 0x21, 0x00,
    0xfc, 0x42, 0x83, 0x37, 0x83, 0x2d, 0x83, 0x10, 0x83, 0x15, 0xa9, 0x80,
    0x15, 0x04, 0x4d, 0x6f, 0x72, 0x73, 0x21, 0x00, 0xfc, 0x42, 0x67, 0x37,
    0x67, 0x2d, 0x67, 0x12, 0x67, 0x15, 0xa9, 0x80, 0x15, 0x04, 0x53, 0x61,
    0x6e, 0x69, 0x74, 0x61, 0x73, 0x21, 0x00, 0xfc, 0x42, 0x83, 0x37, 0x83,
    0x2d, 0x83, 0x10, 0x83, 0x15, 0xa9, 0x80, 0x0c, 0x84, 0x01, 0x40, 0x04,
    0x00, 0x00, 0x28, 0x11, 0x11, 0x28, 0x80, 0x02, 0x13, 0xff, 0xff, 0x23,
    0x00, 0x00, 0x4c, 0xfe, 0x7b, 0xc0, 0x44, 0xc0, 0x42, 0xc0, 0x45, 0xc0,
    0x48, 0xc0, 0x43, 0x15, 0x04, 0x4f, 0x72, 0x61, 0x74, 0x69, 0x6f, 0x21,
    0x00, 0xfc, 0x42, 0x9b, 0x37, 0x9b, 0x2d, 0x9f, 0x10, 0x9f, 0x15, 0xa9,
    0x80, 0x11, 0x56, 0x69, 0x74, 0x61, 0x21, 0x00, 0x15, 0xa9, 0x80, 0x15,
    0x04, 0x53, 0x61, 0x6e, 0x69, 0x74, 0x61, 0x73, 0x21, 0x00, 0xfc, 0x42,
    0x83, 0x37, 0x83, 0x2d, 0x83, 0x10, 0x83, 0x15, 0xa9, 0x80, 0x15, 0x04,
    0x4d, 0x6f, 0x72, 0x73, 0x21, 0x00, 0xfc, 0x42, 0x67, 0x37, 0x67, 0x2d,
    0x67, 0x12, 0x67, 0x15, 0xa9, 0x80, 0x15, 0x04, 0x4f, 0x72, 0x61, 0x74,
    0x69, 0x6f, 0x21, 0x00, 0xfc, 0x42, 0x9b, 0x37, 0x9b, 0x2d, 0x9f, 0x10,
    0x9f, 0x15, 0xa9, 0x80, 0x15, 0x04, 0x4d, 0x6f, 0x72, 0x73, 0x21, 0x00,
    0xfc, 0x42, 0x67, 0x37, 0x67, 0x2d, 0x67, 0x12, 0x67, 0x15, 0xa9, 0x80,
    0x11, 0x56, 0x69, 0x74, 0x61, 0x21, 0x00, 0x15, 0xa9, 0x80, 0x15, 0x04,
    0x4f, 0x72, 0x61, 0x74, 0x69, 0x6f, 0x21, 0x00, 0xfc, 0x42, 0x9b, 0x37,
    0x9b, 0x2d, 0x9f, 0x10, 0x9f, 0x15, 0xa9, 0x80, 0x15, 0x04, 0x4d, 0x6f,
    0x72, 0x73, 0x21, 0x00, 0xfc, 0x42, 0x67, 0x37, 0x67, 0x2d, 0x67, 0x12,
    0x67, 0x15, 0xa9, 0x80,
};
static struct TypedBlock const k_osrs234_frame_blocks[] = {
    { 0, 12212, 4, { 33602, 33591, 33581, 33552 } },
    { 1, 12212, 4, { 26434, 26423, 26413, 26386 } },
    { 2, 12212, 4, { 33602, 33591, 33581, 33552 } },
    { 4, 12212, 4, { 39746, 39735, 40749, 40720 } },
    { 6, 12212, 4, { 33602, 33591, 33581, 33552 } },
    { 7, 12212, 4, { 26434, 26423, 26413, 26386 } },
    { 8, 12212, 4, { 39746, 39735, 40749, 40720 } },
    { 9, 12212, 4, { 26434, 26423, 26413, 26386 } },
    { 11, 12212, 4, { 39746, 39735, 40749, 40720 } },
    { 12, 12212, 4, { 26434, 26423, 26413, 26386 } },
};

static RsprotInfoOp g_ops[4096];
static uint8_t g_bytes[1 << 16];

/* The two types the real frames name, as the cache has them; and for the
 * hand-built rev 222 packet, the kept npc's type (5) and the one its record
 * turns it into (900, 2). */
static int g_asked_old;
static int g_asked_type;

static int
lengths(
    void* ctx,
    int old,
    int npc_type,
    int head,
    int* recolours,
    int* retextures)
{
    (void)ctx;
    (void)head;
    g_asked_old = old;
    g_asked_type = npc_type;
    *retextures = 0;
    if( npc_type == 12375 )
        *recolours = 3;
    else if( npc_type == 12212 )
        *recolours = 4;
    else if( npc_type == 900 )
        *recolours = 2;
    else if( npc_type < 0 && old == 0 )
        *recolours = 5;
    else
        return 0;
    return 1;
}

static void
check_frame(
    char const* name,
    RsprotNpcInfoReadFn read,
    uint8_t const* frame,
    int len,
    struct TypedBlock const* blocks,
    int block_count)
{
    RsprotInfoList list;
    int n;
    int position = -1;
    int seen = 0;
    int wrong = 0;

    printf("%s: a real NPC_INFO_LARGE with typed recolours\n", name);
    rsprot_info_list_init(&list, g_ops, 4096, g_bytes, (int)sizeof(g_bytes));
    n = proto_info_npc_read(read, frame, len, lengths, NULL, &list);
    CHECK(rsprot_info_list_complete(&list), "the whole packet is read, to its last byte");
    for( int i = 0; i < n; i++ )
    {
        RsprotInfoOp const* op = &g_ops[i];

        if( op->kind == RSPROT_OP_SET_EXT )
            position = (int)op->value;
        if( op->kind != RSPROT_OP_BODY_CUSTOM || op->body.recolour_count == 0 )
            continue;
        if( seen >= block_count || blocks[seen].position != position ||
            blocks[seen].count != op->body.recolour_count )
            wrong++;
        else
            for( int k = 0; k < op->body.recolour_count; k++ )
                wrong += op->body.recolours[k] != blocks[seen].recolours[k];
        seen++;
    }
    CHECK(seen == block_count, "every typed block the transcript shows is read");
    CHECK(wrong == 0, "each at its npc, with the transcript's colours");
}

/* Rev 222 reads TRANSFORMATION before BODY_CUSTOMISATION: the body block of a
 * record that retyped its npc reads the NEW type's counts. A kept npc (list
 * position 0, old index 0, type with five) turns into type 900 (two). */
static void
check_retype_first(void)
{
    static uint8_t packet[32];
    RsprotInfoList list;
    RsprotBuf b;
    int n;
    int found = 0;

    printf("osrs222: a record that retypes its npc reads the new type's counts\n");
    rsprot_buf_wrap(&b, packet, (int)sizeof(packet));
    rsprot_p1(&b, 0x01); /* one npc in view */
    rsprot_p1(&b, 0x9F); /* kept, stood still with extended info; 0xFFFF... */
    rsprot_p1(&b, 0xFF);
    rsprot_p1(&b, 0xE0); /* ...the terminator, then the pad */
    rsprot_p1(&b, 0x08 | 0x01); /* TRANSFORMATION, and a second byte */
    rsprot_p1(&b, 0x02);        /* BODY_CUSTOMISATION (0x200) */
    rsprot_p2_21_add128(&b, 900);
    rsprot_p1(&b, 0x4);
    rsprot_p2_12_add128(&b, 7001);
    rsprot_p2_12_add128(&b, 7002);
    rsprot_info_list_init(&list, g_ops, 4096, g_bytes, (int)sizeof(g_bytes));
    g_asked_old = -2;
    g_asked_type = -2;
    n = proto_info_npc_read(npc_info_small_v4_osrs222, packet, b.wpos, lengths, NULL, &list);
    CHECK(rsprot_info_list_complete(&list), "the packet is read whole");
    CHECK(g_asked_old == -1 && g_asked_type == 900, "the question names the type the record turned it into");
    for( int i = 0; i < n; i++ )
        if( g_ops[i].kind == RSPROT_OP_BODY_CUSTOM && g_ops[i].body.recolour_count == 2 &&
            g_ops[i].body.recolours[0] == 7001 && g_ops[i].body.recolours[1] == 7002 )
            found = 1;
    CHECK(found, "and the block carries that type's two colours");

    /* The kept npc's own type, without the retype: asked by its old index. */
    rsprot_buf_wrap(&b, packet, (int)sizeof(packet));
    rsprot_p1(&b, 0x01);
    rsprot_p1(&b, 0x9F);
    rsprot_p1(&b, 0xFF);
    rsprot_p1(&b, 0xE0);
    rsprot_p1(&b, 0x01);
    rsprot_p1(&b, 0x02);
    rsprot_p1(&b, 0x4);
    for( int i = 0; i < 5; i++ )
        rsprot_p2_12_add128(&b, 8000 + i);
    rsprot_info_list_init(&list, g_ops, 4096, g_bytes, (int)sizeof(g_bytes));
    n = proto_info_npc_read(npc_info_small_v4_osrs222, packet, b.wpos, lengths, NULL, &list);
    CHECK(rsprot_info_list_complete(&list), "a kept npc's block reads whole");
    CHECK(g_asked_old == 0 && g_asked_type == -1, "asked by the npc's index in the host's list");
    found = 0;
    for( int i = 0; i < n; i++ )
        if( g_ops[i].kind == RSPROT_OP_BODY_CUSTOM && g_ops[i].body.recolour_count == 5 &&
            g_ops[i].body.recolours[4] == 8004 )
            found = 1;
    CHECK(found, "with its type's five colours");

    /* An answer the payload cannot hold ends the read at the block, before
     * any colour is taken from past the end. */
    rsprot_buf_wrap(&b, packet, (int)sizeof(packet));
    rsprot_p1(&b, 0x01);
    rsprot_p1(&b, 0x9F);
    rsprot_p1(&b, 0xFF);
    rsprot_p1(&b, 0xE0);
    rsprot_p1(&b, 0x01);
    rsprot_p1(&b, 0x02);
    rsprot_p1(&b, 0x4);
    rsprot_p2_12_add128(&b, 8000); /* one of the five */
    rsprot_info_list_init(&list, g_ops, 4096, g_bytes, (int)sizeof(g_bytes));
    n = proto_info_npc_read(npc_info_small_v4_osrs222, packet, b.wpos, lengths, NULL, &list);
    CHECK(list.stopped && n > 0 && g_ops[n - 1].kind == RSPROT_OP_STOP &&
              g_ops[n - 1].stop.kind == RSPROT_IK_CUSTOM_TYPED,
        "a count longer than the payload left stops the read at its block");
}

int
main(void)
{
    check_frame("osrs226", npc_info_large_v5_osrs226, k_osrs226_frame, (int)sizeof(k_osrs226_frame),
        k_osrs226_frame_blocks, (int)(sizeof(k_osrs226_frame_blocks) / sizeof(k_osrs226_frame_blocks[0])));
    check_frame("osrs234", npc_info_large_v5_osrs234, k_osrs234_frame, (int)sizeof(k_osrs234_frame),
        k_osrs234_frame_blocks, (int)(sizeof(k_osrs234_frame_blocks) / sizeof(k_osrs234_frame_blocks[0])));
    check_retype_first();
    if( g_failures )
    {
        printf("npc_info_typed_custom: %d failures\n", g_failures);
        return 1;
    }
    printf("npc_info_typed_custom: all passed\n");
    return 0;
}
